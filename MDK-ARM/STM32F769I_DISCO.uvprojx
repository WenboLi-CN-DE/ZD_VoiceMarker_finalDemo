# Keil uVision project STM32F769I_DISCO.uvprojx, settings and files
target STM32F769I_DISCO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_DISCO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769x,NDEBUG,STM32F769xx
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common;../LIBJPEG/App;../LIBJPEG/Target;../Utilities/JPEG;../Middlewares/Third_Party/LibJPEG/include;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Drivers/BSP/STM32F769I-Discovery;../Drivers/BSP/Components/wm8994;../Middlewares/Third_Party/common;../Middlewares/Third_Party/cyclone_tcp;../Middlewares/Third_Party/cJson;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: STM32F769I_DISCO.sct
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp Buttons.cpp KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp tgfx_jpeg_utils.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/Core
    ../Core/Src/: explorer.c menu.c waveplayer.c waverecorder.c debug.c JsonParser.c UnixParser.c User_Button_LED.c main.c freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/wm8994/: wm8994.c
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_i2s.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Application/User/LIBJPEG/App
    ../LIBJPEG/App/: libjpeg.c
  group Middlewares/LibJPEG
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
    ../Middlewares/Third_Party/LibJPEG/source/: jcapimin.c jcapistd.c jdapimin.c jdapistd.c jcomapi.c jcparam.c jctrans.c jdtrans.c jcinit.c jcmaster.c jcmainct.c jcprepct.c jccoefct.c jccolor.c jcsample.c jcdctmgr.c jfdctint.c jfdctfst.c jfdctflt.c jchuff.c jcarith.c jcmarker.c jdatadst.c jdmaster.c jdinput.c jdmainct.c jdcoefct.c jdpostct.c jdmarker.c jdhuff.c jdarith.c jddctmgr.c jidctint.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jdmerge.c jquant1.c jquant2.c jdatasrc.c jaricom.c jerror.c jmemmgr.c jutils.c jmemnobs.c
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sdram.c sdram_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/LIBJPEG/Target
    ../LIBJPEG/Target/: jdata_conf.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group gui
    ../touchgfx/gui/src/containers/: customcontainer1.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/mainboard_screen/: mainboardpresenter.cpp mainboardview.cpp
    ../touchgfx/gui/src/markerhistory_screen/: markerhistorypresenter.cpp markerhistoryview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
    ../touchgfx/gui/src/sub_information_screen/: sub_informationpresenter.cpp sub_informationview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_arial_30_4bpp_0.cpp font_consola_20_4bpp_0.cpp font_verdana_10_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_arial_30_4bpp.cpp kerning_consola_20_4bpp.cpp kerning_verdana_10_4bpp.cpp table_arial_30_4bpp.cpp table_consola_20_4bpp.cpp table_verdana_10_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_background.cpp image_e-1156000-300b6c29.cpp image_ic_action_arrow_left.cpp image_ic_action_arrow_left_light.cpp image_ic_action_camera.cpp image_ic_action_camera_light.cpp image_ic_action_car.cpp image_ic_action_coffee.cpp image_ic_action_coffee_light.cpp image_ic_action_folder_open.cpp image_ic_action_folder_open_light.cpp image_ic_action_gear.cpp image_ic_action_gear_light.cpp image_ic_action_globe.cpp image_ic_action_globe_dark.cpp image_ic_action_goleft.cpp image_ic_action_goright.cpp image_ic_action_info.cpp image_ic_action_info_light.cpp image_ic_action_info_small.cpp image_ic_action_info_small_dark.cpp image_ic_action_line_chart.cpp image_ic_action_line_chart_light.cpp image_ic_action_location_2.cpp image_ic_action_mic.cpp image_ic_action_mic_light.cpp image_ic_action_minus.cpp image_ic_action_playback_forw.cpp image_ic_action_playback_forw_light.cpp image_ic_action_playback_next.cpp image_ic_action_playback_pause.cpp image_ic_action_playback_pause_dark.cpp image_ic_action_playback_play.cpp image_ic_action_playback_play_dark.cpp image_ic_action_playback_prev.cpp image_ic_action_playback_repeat.cpp image_ic_action_playback_repeat_1.cpp image_ic_action_playback_rew.cpp image_ic_action_playback_rew_light.cpp image_ic_action_playback_schuffle.cpp image_ic_action_playback_stop.cpp image_ic_action_playback_stop_dark.cpp image_ic_action_record.cpp image_ic_action_tick.cpp image_ic_action_volume.cpp image_ic_action_volume_mute.cpp image_ic_action_volume_up.cpp image_logo.cpp image_sologan.cpp
    ../touchgfx/generated/gui_generated/src/containers/: customcontainer1base.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__designer/: image_blue_backgrounds_main_bg_800x480px.cpp image_blue_backgrounds_main_bg_texture_800x480px.cpp image_blue_buttons_round_edge_icon_button.cpp image_blue_buttons_round_edge_icon_button_pressed.cpp image_blue_buttons_round_edge_small.cpp image_blue_buttons_round_edge_small_pressed.cpp image_blue_buttons_round_icon_button.cpp image_blue_buttons_round_icon_button_pressed.cpp image_blue_buttons_round_large.cpp image_blue_buttons_round_large_pressed.cpp image_blue_buttons_square_icon_button.cpp image_blue_buttons_square_icon_button_pressed.cpp image_blue_buttons_square_small.cpp image_blue_buttons_square_small_pressed.cpp image_blue_icons_add_new_32.cpp image_blue_icons_next_arrow_32.cpp image_blue_icons_pause_32.cpp image_blue_icons_play_32.cpp image_blue_icons_refresh_32.cpp image_blue_icons_stop_32.cpp image_blue_slider_vertical_medium_indicators_slider3_vertical_round_nob.cpp image_blue_slider_vertical_medium_slider3_vertical_round_back.cpp image_blue_slider_vertical_medium_slider3_vertical_round_fill.cpp image_blue_togglebars_toggle_round_small_button_off.cpp image_blue_togglebars_toggle_round_small_button_on.cpp image_dark_backgrounds_main_bg_480x272px.cpp image_dark_buttons_round_icon_button_pressed.cpp
    ../touchgfx/generated/images/src/mdpi/: image_yellowdark10.cpp image_yellowdark11.cpp image_yellowdark12.cpp image_yellowdark13.cpp image_yellowdark14.cpp image_yellowdark15.cpp image_yellowdark176.cpp image_yellowdark177.cpp image_yellowdark178.cpp image_yellowdark179.cpp image_yellowdark180.cpp image_yellowdark181.cpp image_yellowdark182.cpp image_yellowdark183.cpp image_yellowdark184.cpp image_yellowdark185.cpp image_yellowdark193.cpp image_yellowdark194.cpp image_yellowdark195.cpp image_yellowdark196.cpp image_yellowdark204.cpp image_yellowdark208.cpp image_yellowdark215.cpp image_yellowdark222.cpp image_yellowdark230.cpp image_yellowdark231.cpp image_yellowdark235.cpp image_yellowdark236.cpp image_yellowdark241.cpp image_yellowdark242.cpp image_yellowdark243.cpp image_yellowdark244.cpp image_yellowdark8.cpp image_yellowdark9.cpp image_yellowdarkbig1.cpp image_yellowdarkbig10.cpp image_yellowdarkbig2.cpp image_yellowdarkbig3.cpp image_yellowdarkbig4.cpp image_yellowdarkbig5.cpp image_yellowdarkbig6.cpp image_yellowdarkbig7.cpp image_yellowdarkbig8.cpp image_yellowdarkbig9.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/mainboard_screen/: mainboardviewbase.cpp
    ../touchgfx/generated/gui_generated/src/markerhistory_screen/: markerhistoryviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
    ../touchgfx/generated/gui_generated/src/sub_information_screen/: sub_informationviewbase.cpp
  group Driver/BSP/STM32F769I_Discovery
    ../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_audio.c stm32f769i_discovery_eeprom.c stm32f769i_discovery_qspi.c stm32f769i_discovery_sdram.c
  group Common Sources
    ../Middlewares/Third_Party/common/: cpu_endian.c os_port_freertos.c str.c date_time.c
  group Config Headers
    ../Core/Inc/: os_port_config.h
    ../Middlewares/Third_Party/common/: cpu_endian.h os_port.h str.h error.h date_time.h
  group CycloneTCP Sources
    ../Middlewares/Third_Party/cyclone_tcp/core/: net.c net_mem.c net_misc.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_misc.c raw_socket.c nic.c
    ../Middlewares/Third_Party/cyclone_tcp/drivers/phy/: lan8742_driver.c
    ../Middlewares/Third_Party/cyclone_tcp/ipv4/: ipv4.c ipv4_frag.c ipv4_misc.c arp.c icmp.c
    ../Middlewares/Third_Party/cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c
    ../Middlewares/Third_Party/cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c icmpv6.c ndp_misc.c ipv6_pmtu.c mld.c ndp.c ndp_cache.c slaac.c slaac_misc.c
    ../Middlewares/Third_Party/cyclone_tcp/dns/: dns_client.c dns_cache.c dns_common.c dns_debug.c
    ../Middlewares/Third_Party/cyclone_tcp/dhcp/: dhcp_common.c dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_debug.c
    ../Middlewares/Third_Party/cyclone_tcp/http/: http_client.c http_common.c http_client_misc.c http_client_transport.c
    ../Middlewares/Third_Party/cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../Middlewares/Third_Party/cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../Middlewares/Third_Party/cyclone_tcp/netbios/: nbns_client.c nbns_common.c nbns_responder.c
    ../Middlewares/Third_Party/cyclone_tcp/drivers/mac/: stm32f7xx_eth_driver.c
    ../Middlewares/Third_Party/cyclone_tcp/ftp/: ftp_client.c ftp_client_misc.c ftp_client_transport.c
  group Middlewares/cJson
    ../Middlewares/Third_Party/cJson/: cJSON.c cJSON_Utils.c
software components: CMSIS:CORE 5.5.0
